Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Itaca-Pouf - ver4.ifc
Time: 2025-11-13T15:34:30
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (11)
Name
 | Itaca-Pouf_0 - ObjectType: SketchupGroup
 | Itaca-Pouf_1 - ObjectType: SketchupGroup
 | Itaca-Pouf_2 - ObjectType: SketchupGroup
 | Itaca-Pouf_3 - ObjectType: SketchupGroup
 | Itaca-Pouf_4 - ObjectType: SketchupGroup
 | Itaca-Pouf_5 - ObjectType: SketchupGroup
 | Itaca-Pouf_6 - ObjectType: SketchupGroup
 | Itaca-Pouf_7 - ObjectType: SketchupGroup
 | Itaca-Pouf_8 - ObjectType: SketchupGroup
 | Itaca-Pouf_9 - ObjectType: SketchupGroup
 | Itaca-Pouf_10 - ObjectType: SketchupGroup
